# Keil uVision project lab5e5.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: LPC4072FBD80 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IRAM(0x10000000,0x4000) IRAM2(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: lab5e5
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
